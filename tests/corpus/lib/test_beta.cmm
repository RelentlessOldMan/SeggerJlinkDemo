PRINT "beta"
ENDDO
