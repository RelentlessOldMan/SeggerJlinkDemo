PRINT "alpha"
ENDDO
