PRINT "gamma"
ENDDO
