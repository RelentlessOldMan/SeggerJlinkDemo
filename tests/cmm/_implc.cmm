&implc="c"
ENDDO
